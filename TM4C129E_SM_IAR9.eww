<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Projects\Exerc_16\src\Exerc_16.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\Exerc_17\src\Exerc_17.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\Exerc_18\src\Exerc_18.ewp</path>
    </project>
    <batchBuild />
</workspace>
